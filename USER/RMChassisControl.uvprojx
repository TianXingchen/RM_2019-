# Keil uVision project RMChassisControl.uvprojx, settings and files
target RMChassisControl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: gimbal +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\SYSTEM\DELAY;..\SYSTEM\SYS;..\SYSTEM\USART;..\HARDWARE\BSP;..\HARDWARE\CAN1;..\HARDWARE\DBUS;..\HARDWARE\BEEP;..\HARDWARE\SOLVER;..\HARDWARE\CHASSISIPID;..\HARDWARE\VISUALSCOPE;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\POWER;..\HARDWARE\CONTROLLOOP;..\SYSTEM\usart3;..\JUDGE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/USART/: usart.c
    ../SYSTEM/usart3/: usart3.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/CAN1/: can1.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SOLVER/: solver.c
    ../HARDWARE/CHASSISIPID/: chassispid.c
    ../HARDWARE/VISUALSCOPE/: visualscope.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CONTROLLOOP/: controlloop.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_tim.c
  group README
    ../README/: README.txt
  group JUDGE
    ../JUDGE/: judge.c
